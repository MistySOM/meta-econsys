IMAGE_INSTALL_append = " ecam-ar0234"
IMAGE_INSTALL_append = " ecam-imx462"
IMAGE_INSTALL_append = " econ-enable-script"
